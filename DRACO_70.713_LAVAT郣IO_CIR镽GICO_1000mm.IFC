Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: DRACO_70.713_LAVATÓRIO_CIRÚRGICO_1000mm.IFC
Time: 2023-05-10T14:32:26
Written by: SwIFC
Made in: SolidWorks 2022

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: DRACO_70.713_LAVATÓRIO_CIRÚRGICO_1000mm
In: Default Storey
Material: AISI 304
